## config/boards/shields/dumbpad/Kconfig.shield
```kconfig
# SPDX-License-Identifier: MIT

config SHIELD_DUMBPAD
    def_bool $(shields_list_contains,dumbpad)
```
